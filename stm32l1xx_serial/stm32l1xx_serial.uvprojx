# Keil uVision project stm32l1xx_serial.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L100RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32l1xx_serial
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: delay.c lcd.c main.c usart.c util.c
    ./libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_gpio1.c stm32l1xx_rcc1.c stm32l1xx_usart1.c
software components: CMSIS:CORE 5.0.2, Device:Startup 2.0.0
